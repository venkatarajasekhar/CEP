# Keil uVision project Project.uvproj, settings and files
target cep (ARM-ADS)
  device: STM32F417VG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: cep
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\StdPeriph_Driver\inc;.\Libraries\Device;.\Libraries\TiLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Project
    ./Project/: main.c global.h labor5.h labor5.c spi.c spi.h spi_mem.h spi_mem.c gpio.h gpio.c
    ./Project/tests/: spi_mem_test.h spi_mem_test.c
  group CMSIS
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ./Libraries/StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_i2c.c
    ./Libraries/Device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group StdPeriph_Driver_h
    ../../../Libraries/StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_fsmc.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
    ./Libraries/StdPeriph_Driver/inc/: stm32f4xx_spi.h stm32f4xx_gpio.h
    ./Libraries/Device/: stm32f4xx.h
  group TiLib
    ./Libraries/TiLib/: CE_Lib.c Usart.c Retarget.c tft.c
